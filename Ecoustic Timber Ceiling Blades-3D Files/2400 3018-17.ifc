Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2018-07-10T12:42:12
Organization: Instyle
Made in: ASIFC - 2.9.0.828

# IfcProject
LongName: 3018-17

# IfcSite, Site
RefLatitude: 47, 35, 59, 994506; RefLongitude: -122, -17, -59, -983520; RefElevation: 0 mm

# IfcProxy (18)
ProxyType: PRODUCT
